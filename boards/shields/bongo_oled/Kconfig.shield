## boards/shields/bongo_oled/Kconfig.shield
```kconfig
config SHIELD_BONGO_OLED
    bool "Bongo Cat OLED shield"
    depends on SHIELD
    default y
```
